# Keil uVision project Project.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: stm32f10x_it.c main.c timer.c MyStdlib.c
  group bsp
    ../bsp/: bsp.c watchdog.c
  group memory
    ../memory/: spi.c
  group nrf24L01
    ../NRF24L01/: nrf24l01.c
  group FWLib
    D:/Program Files/KeilARM350/ARM/RV31/LIB/ST/: STM32F10xR.LIB
  group RVMDK
    ./: stm32f10x_vector.s
  group Doc
    ./: readme.txt
target RAM (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: STM32
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: "VECT_TAB_RAM"
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x3000
  memory RVCT9: RAM 0x20003000 size 0x2000
target Simulator (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: STM32
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target FLASH-IAP (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: as above
  output: stm32 +hex
  AfterMake: encrypt.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: "VECT_TAB_FLASH_IAP"
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x5000
